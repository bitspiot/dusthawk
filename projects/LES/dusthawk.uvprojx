# Keil uVision project dusthawk.uvprojx, settings and files
target Target (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dusthawk
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1,ARM_MATH_CM4,__FPU_PRESENT=1
  c misc: --c99
  c include: ..\..\..\project_dust_hawk;..\..\third_party;..\..\CMSIS\4.5.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\dusthawk.sct
  link misc: --entry Reset_Handler
  group app
    ./: main.c startup_rvmdk.S bsp.c lcd.c rtc.c buttons.c
    ../../utils/: uartstdio.c
    ../../third_party/fatfs/port/: dual_disk_drv.c
    ../../dusthawk_les/: dh.c
    ../../third_party/fatfs/src/: ff.c
  group lib
    ../../driverlib/rvmdk/: driverlib.lib
    ../../usblib/rvmdk/: usblib.lib
    ../../CMSIS/4.5.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
